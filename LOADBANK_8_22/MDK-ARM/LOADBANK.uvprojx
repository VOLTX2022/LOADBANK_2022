# Keil uVision project LOADBANK.uvprojx, settings and files
target LOADBANK (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F051R8Tx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.1
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: LOADBANK +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F051x8
  c include: ../Inc;  ../Drivers/STM32F0xx_HAL_Driver/Inc;  ../Drivers/STM32F0xx_HAL_Driver/Inc/Legacy;  ../Drivers/CMSIS/Device/ST/STM32F0xx/Include;  ../Drivers/CMSIS/Include;  ..\application;  ..\arrays_calibration_firing;  ..\auto_mode;  ..\configration;  ..\firing;  ..\hmi_communication;  ..\hmi_handler;  ..\measurement;  ..\pid;  ..\pid_handler;  ..\queue_dgus_rx;  ..\time_handler;  ..\measurement_history;  ..\time_based_table_operation;  ..\time_based_table_operation;  ..\feedback_handler;  ..\capacity_measurement;  ..\capacity_measurement;  ..\feedback_handler;  ..\display_iterration;  ..\display_iterration
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Application/MDK-ARM
    ./: startup_stm32f051x8.s
  group Application/User
    ../application/: application.c
    ../arrays_calibration_firing/: arrays_calibration_firing.c
    ../auto_mode/: auto_mode.c
    ../configration/: configration.c
    ../firing/: firing.c
    ../hmi_communication/: hmi_communication.c
    ../hmi_handler/: hmi_handler.c
    ../measurement/: measurement.c
    ../pid/: pid.c
    ../pid_handler/: pid_handler.c
    ../queue_dgus_rx/: queue_dgus_rx.c
    ../time_handler/: time_handler.c
    ../measurement_history/: measurement_history.c
    ../time_based_table_operation/: time_based_table_operation.c
    ../feedback_handler/: feedback_handler.c
    ../capacity_measurement/: capacity_measurement.c
    ../display_iterration/: display_iterration.c
    ../Src/: main.c gpio.c adc.c dma.c tim.c usart.c stm32f0xx_it.c stm32f0xx_hal_msp.c
  group Drivers/STM32F0xx_HAL_Driver
    ../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal_adc.c stm32f0xx_hal_adc_ex.c stm32f0xx_hal_tim.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_uart.c stm32f0xx_hal_uart_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal.c stm32f0xx_hal_i2c.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_dma.c stm32f0xx_hal_cortex.c stm32f0xx_hal_pwr.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_flash.c stm32f0xx_hal_flash_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32f0xx.c
software components: CMSIS:CORE 4.3.0
